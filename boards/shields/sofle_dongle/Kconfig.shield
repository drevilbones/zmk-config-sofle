## boards/shields/sofle_dongle/Kconfig.shield
```kconfig
config SHIELD_MY_SOFLE_DONGLE
    def_bool $(shields_list_contains,sofle_dongle)
```
